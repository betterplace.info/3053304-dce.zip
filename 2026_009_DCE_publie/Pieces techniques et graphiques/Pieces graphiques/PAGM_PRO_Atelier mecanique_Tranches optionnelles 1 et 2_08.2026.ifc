Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture]
Time: 2026-06-17T10:46:54
Made in: cadwork version 32.0 Build 407

# IfcSite, Site
Description: IfcSite; RefElevation: 0 m

# IfcBuildingStorey (2)
Elevation: 0 m
Name | In
Storey 1 | Building 1
Storey create for export | Building create for export

# IfcBeam (67)
PredefinedType: BEAM
Cadwork3dProperties - No. production list: 0
Name | In | Material | Group | Sub group
7 x Semelle filante 50x15ht | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Semelle filante 50x15ht
8 x Dalle 15cm | Storey 1 | Ciment clair | Fondation et ouvrage de maçonnerie | Radier BA 15cm lissé
26 x Mur agglo 15cm + Enduit | Storey 1 | Parpaing | Fondation et ouvrage de maçonnerie | Mur agglo 15cm + Enduit
11 x Massif 60x60x30 | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Massif 60x60x30
Dalle renforcée 18cm | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Radier BA renforcé 18cm lissé
4 x Dalle renforcée 18cm | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Radier BA 15cm lissé
Fut 20x20x15ht | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Massif 60x60x30
8 x Rideau métallique | Storey 1 | Acier | Façade | Façade
Mur agglo 15cm + Enduit | Storey create for export | Parpaing | Fondation et ouvrage de maçonnerie | Mur agglo 15cm + Enduit

# IfcBuildingElementProxy (36)
In: Storey 1
Cadwork3dProperties - No. production list: 0
Name | Group | Sub group
19 x  | Fondation et ouvrage de maçonnerie | Axe
5 x S-PLEINE | Façade | Façade | Material: Gonfolo; Cadwork3dProperties - SKU: PD-Plein; Utilisateur 10: ELE-F1à10
Terrain neutre | Fondation et ouvrage de maçonnerie | Material: Gazon
5 x Bac acier 63/100 - Type PROFIL Guyane 4200 | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Bac acier
4 x Solin Cranté | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Tole plane
2 x Faitâge cranté | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Tole plane

# IfcColumn (7)
In: Storey 1
PredefinedType: COLUMN
Cadwork3dProperties - No. production list: 0
Name | Material | Group | Sub group
6 x 33466A TILOS Brown ceiling fan | PVC | Electrical Fixtures | 33466A
Porte métallique double battant | Acier | Façade | Façade

# IfcMember (1881)
In: Storey 1
Cadwork3dProperties - No. production list: 0
Name | Material | Group | Sub group
419 x Rideau métallique | Acier Galvanisé | Façade | Façade
102 x 33466A TILOS Brown ceiling fan | PVC | Electrical Fixtures | 33466A
16 x Raidisseur 15x15 | Béton | Fondation et ouvrage de maçonnerie | Raidisseurs et chainage | PredefinedType: STUD
12 x 33466A TILOS Brown ceiling fan | Acier | Electrical Fixtures | 33466A
6 x Bati cellumat 100 - 50x120 | ANG | Façade | Façade | PredefinedType: STUD
15 x Raidisseur 15x250 | Béton | Fondation et ouvrage de maçonnerie | Raidisseurs et chainage | PredefinedType: STUD
23 x Rideau métallique | Acier | Façade | Façade | PredefinedType: STUD
104 x Bardage 22mm + Support 55x85 + Isolant thermique 80mm | Angélique-Revêtement | Option | Option 1 - Bardage sur maçonnerie | Cadwork3dProperties - SKU: PD-Plein
12 x 33466A TILOS Brown ceiling fan | PVC | Electrical Fixtures | 33466A | PredefinedType: STUD
13 x Porte métallique double battant | Acier Galvanisé | Façade | Façade | PredefinedType: STUD
6 x 33466A TILOS Brown ceiling fan | Acier | Electrical Fixtures | 33466A | PredefinedType: STUD
91 x Poteau moisé 50/50/150 | ANG | Charpente bois local | Ferme et poteau | PredefinedType: STUD
12 x Béquille sur plaque aluminium | Acier | Façade | Façade
 | Acier | Façade | Façade | PredefinedType: STUD
6 x 33466A TILOS Brown ceiling fan | BA13 | Electrical Fixtures | 33466A
6 x Béquille sur plaque aluminium | Acier | Façade | Façade | PredefinedType: STUD
3 x PI93 âme pleine prépeint | Fermacell | Façade | Façade | PredefinedType: STUD
3 x Porte métallique double battant | Acier | Façade | Façade | PredefinedType: STUD
41 x Chevron 50x80 | ANG | PredefinedType: STUD
15 x DEP aluminium 70x110 | Zinc | Lot 02 | EP | PredefinedType: STUD; Cadwork3dProperties - Partie bâtiment: Charpente
11 x Pied de poteau | Acier Galvanisé | Charpente bois local | Ferme et poteau
25 x Pied de poteau | Acier Galvanisé | Charpente bois local | Ferme et poteau | PredefinedType: STUD
4 x Porte métallique double battant | Acier Galvanisé | Façade | Façade
51 x Lien 50x120 | ANG | Charpente bois local | Ferme et poteau
5 x DEP aluminium 70x110 | Zinc | Lot 02 | EP | Cadwork3dProperties - Partie bâtiment: Charpente
68 x Echantignole | ANG | Charpente bois local | Pannes, chevrons, supports de couverture
48 x Arba/entrait 50x120 | ANG | Charpente bois local | Ferme et poteau
28 x Panne 50x150 | ANG | Charpente bois local | Pannes, chevrons, supports de couverture
27 x Raidisseur et chainage | Béton | Fondation et ouvrage de maçonnerie | Raidisseurs et chainage
7 x Lien 50x120 | ANG | Charpente bois local | Ferme et poteau | PredefinedType: STUD
17 x ArbaLétrier 50x150 | ANG | Charpente bois local | Ferme et poteau
13 x Lisse d'ossature | ANG | Façade | Habillage en tasseau bois | PredefinedType: STUD
19 x Lisse d'ossature | ANG | Façade | Habillage en tasseau bois
524 x Tasseau 50x50 | ANG | Façade | Habillage en tasseau bois | PredefinedType: STUD
26 x Traverse 120x120 | ANG | Charpente bois local | Ferme et poteau
32 x CV 120x120 | ANG | Charpente bois local | Ferme et poteau
10 x Planche de rive 22x200 | GRG | Couverture et gestion des EP | Planches de rive périphériques
4 x Poinçon | ANG | Charpente bois local | Ferme et poteau | PredefinedType: STUD
8 x CV entre panne 50x120 | ANG |  | Pannes, chevrons, supports de couverture
9 x Echantignole 120 | ANG
6 x Panne 50x120 | ANG | Charpente bois local | Pannes, chevrons, supports de couverture
9 x Solive 50x120 | ANG | Charpente bois local | Plancher bois en plafond du stockage
3 x Bati cellumat 100 - 50x120 | ANG | Façade | Façade
6 x Cornière LNP 50x4 | Acier Galvanisé | Façade | Habillage en tasseau bois
12 x Fer plat 50x10 | Acier Galvanisé | Façade | Habillage en tasseau bois | PredefinedType: STUD
3 x Gouttière aluminium Typy G300 | Zinc | Lot 02 | EP | Cadwork3dProperties - Partie bâtiment: Charpente

# IfcPlate (4)
In: Storey 1
Material: OSB 3
Cadwork3dProperties - Group: Charpente bois local; No. production list: 0; Sub group: Plancher bois en plafond du stockage
