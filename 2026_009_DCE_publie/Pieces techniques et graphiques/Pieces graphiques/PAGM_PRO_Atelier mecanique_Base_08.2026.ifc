Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture]
Time: 2026-06-17T10:46:12
Made in: cadwork version 32.0 Build 407

# IfcSite, Site
Description: IfcSite; RefElevation: 0 m

# IfcBuildingStorey, Storey 1
In: Building 1
Elevation: 0 m

# IfcBeam (55)
In: Storey 1
PredefinedType: BEAM
Cadwork3dProperties - No. production list: 0
Name | Material | Group | Sub group
17 x Mur agglo 15cm + Enduit | Parpaing | Fondation et ouvrage de maçonnerie | Mur agglo 15cm + Enduit
8 x Rideau métallique | Acier | Façade | Façade
11 x Massif 60x60x30 | Béton | Fondation et ouvrage de maçonnerie | Massif 60x60x30
7 x Dalle 15cm | Ciment clair | Fondation et ouvrage de maçonnerie | Radier BA 15cm lissé
Dalle renforcée 18cm | Béton | Fondation et ouvrage de maçonnerie | Radier BA renforcé 18cm lissé
6 x Semelle filante 50x15ht | Béton | Fondation et ouvrage de maçonnerie | Semelle filante 50x15ht
4 x Dalle renforcée 18cm | Béton | Fondation et ouvrage de maçonnerie | Radier BA 15cm lissé
Fut 20x20x15ht | Béton | Fondation et ouvrage de maçonnerie | Massif 60x60x30

# IfcBuildingElementProxy (28)
In: Storey 1
Cadwork3dProperties - No. production list: 0
Name | Group | Sub group
5 x Bac acier 63/100 - Type PROFIL Guyane 4200 | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Bac acier
4 x Solin Cranté | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Tole plane
15 x  | Fondation et ouvrage de maçonnerie | Axe
2 x Faitâge cranté | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Tole plane
2 x S-PLEINE | Façade | Façade | Material: Gonfolo; Cadwork3dProperties - SKU: PD-Plein; Utilisateur 10: ELE-F1à10

# IfcColumn, Porte métallique double battant
In: Storey 1
PredefinedType: COLUMN; Material: Acier
Cadwork3dProperties - Group: Façade; No. production list: 0; Sub group: Façade

# IfcMember (1516)
In: Storey 1
Cadwork3dProperties - No. production list: 0
Name | Material | Group | Sub group
419 x Rideau métallique | Acier Galvanisé | Façade | Façade
488 x Tasseau 50x50 | ANG | Façade | Habillage en tasseau bois | PredefinedType: STUD
15 x Raidisseur 15x250 | Béton | Fondation et ouvrage de maçonnerie | Raidisseurs et chainage | PredefinedType: STUD
43 x Bardage 22mm + Support 55x85 + Isolant thermique 80mm | Angélique-Revêtement | Option | Option 1 - Bardage sur maçonnerie | Cadwork3dProperties - SKU: PD-Plein
25 x Pied de poteau | Acier Galvanisé | Charpente bois local | Ferme et poteau | PredefinedType: STUD
64 x Echantignole | ANG | Charpente bois local | Pannes, chevrons, supports de couverture
17 x ArbaLétrier 50x150 | ANG | Charpente bois local | Ferme et poteau
11 x Pied de poteau | Acier Galvanisé | Charpente bois local | Ferme et poteau
48 x Arba/entrait 50x120 | ANG | Charpente bois local | Ferme et poteau
6 x Panne 50x120 | ANG | Charpente bois local | Pannes, chevrons, supports de couverture
51 x Lien 50x120 | ANG | Charpente bois local | Ferme et poteau
32 x CV 120x120 | ANG | Charpente bois local | Ferme et poteau
82 x Poteau moisé 50/50/150 | ANG | Charpente bois local | Ferme et poteau | PredefinedType: STUD
19 x Raidisseur et chainage | Béton | Fondation et ouvrage de maçonnerie | Raidisseurs et chainage
4 x Poinçon | ANG | Charpente bois local | Ferme et poteau | PredefinedType: STUD
7 x Raidisseur 15x15 | Béton | Fondation et ouvrage de maçonnerie | Raidisseurs et chainage | PredefinedType: STUD
11 x Planche de rive 22x200 | GRG | Couverture et gestion des EP | Planches de rive périphériques
8 x CV entre panne 50x120 | ANG |  | Pannes, chevrons, supports de couverture
14 x DEP aluminium 70x110 | Zinc | Couverture et gestion des EP | EP | PredefinedType: STUD; Cadwork3dProperties - Partie bâtiment: Charpente
23 x Rideau métallique | Acier | Façade | Façade | PredefinedType: STUD
26 x Panne 50x150 | ANG | Charpente bois local | Pannes, chevrons, supports de couverture
9 x Echantignole 120 | ANG
26 x Traverse 120x120 | ANG | Charpente bois local | Ferme et poteau
5 x DEP aluminium 70x110 | Zinc | Couverture et gestion des EP | EP | Cadwork3dProperties - Partie bâtiment: Charpente
Gouttière pendante G300 | Zinc | Couverture et gestion des EP | EP | Cadwork3dProperties - Partie bâtiment: Charpente
19 x Lisse d'ossature | ANG | Façade | Habillage en tasseau bois
13 x Lisse d'ossature | ANG | Façade | Habillage en tasseau bois | PredefinedType: STUD
7 x Lien 50x120 | ANG | Charpente bois local | Ferme et poteau | PredefinedType: STUD
13 x Porte métallique double battant | Acier Galvanisé | Façade | Façade | PredefinedType: STUD
2 x Porte métallique double battant | Acier | Façade | Façade | PredefinedType: STUD
4 x Porte métallique double battant | Acier Galvanisé | Façade | Façade
2 x Cornière LNP 50x4 | Acier Galvanisé | Façade | Habillage en tasseau bois
2 x Gouttière pendante G300 | Zinc | Lot 02 | EP | Cadwork3dProperties - Partie bâtiment: Charpente
