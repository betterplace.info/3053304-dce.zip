Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture]
Time: 2026-06-26T07:13:33
Made in: cadwork version 32.0 Build 407

# IfcSite, Site
Description: IfcSite; RefElevation: 0 m

# IfcBuildingStorey (2)
Elevation: 0 m
Name | In
Storey 1 | Building 1
Storey create for export | Building create for export

# IfcBeam (68)
PredefinedType: BEAM
Cadwork3dProperties - No. production list: 0
Name | In | Material | Group | Sub group
8 x Rideau métallique | Storey 1 | Acier | Façade | Façade
11 x Massif 60x60x30 | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Massif 60x60x30
27 x Mur agglo 15cm + Enduit | Storey 1 | Parpaing | Fondation et ouvrage de maçonnerie | Mur agglo 15cm + Enduit
7 x Semelle filante 50x15ht | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Semelle filante 50x15ht
8 x Dalle 15cm | Storey 1 | Ciment clair | Fondation et ouvrage de maçonnerie | Radier BA 15cm lissé
Fut 20x20x15ht | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Massif 60x60x30
Dalle renforcée 18cm | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Radier BA renforcé 18cm lissé
4 x Dalle renforcée 18cm | Storey 1 | Béton | Fondation et ouvrage de maçonnerie | Radier BA 15cm lissé
Mur agglo 15cm + Enduit | Storey create for export | Parpaing | Fondation et ouvrage de maçonnerie | Mur agglo 15cm + Enduit

# IfcBuildingElementProxy (36)
In: Storey 1
Cadwork3dProperties - No. production list: 0
Name | Group | Sub group
19 x  | Fondation et ouvrage de maçonnerie | Axe
5 x Bac acier 63/100 - Type PROFIL Guyane 4200 | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Bac acier
Terrain neutre | Fondation et ouvrage de maçonnerie | Material: Gazon
2 x Faitâge cranté | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Tole plane
4 x Solin Cranté | Couverture et gestion des EP | Couverture bac acier 0,63 | Material: Tole plane
5 x S-PLEINE | Façade | Façade | Material: Gonfolo; Cadwork3dProperties - SKU: PD-Plein; Utilisateur 10: ELE-F1à10

# IfcColumn (7)
In: Storey 1
PredefinedType: COLUMN
Cadwork3dProperties - No. production list: 0
Name | Material | Group | Sub group
6 x 33466A TILOS Brown ceiling fan | PVC | Electrical Fixtures | 33466A
Porte métallique double battant | Acier | Façade | Façade

# IfcMember (2102)
In: Storey 1
Cadwork3dProperties - No. production list: 0
Name | Material | Sub group | Group
51 x Lien 50x120 | ANG | Ferme et poteau | Charpente bois local
7 x Lien 50x120 | ANG | Ferme et poteau | Charpente bois local | PredefinedType: STUD
17 x ArbaLétrier 50x150 | ANG | Ferme et poteau | Charpente bois local
48 x Arba/entrait 50x120 | ANG | Ferme et poteau | Charpente bois local
91 x Echantignole | ANG | Pannes, chevrons, supports de couverture | Charpente bois local
28 x Panne 50x150 | ANG | Pannes, chevrons, supports de couverture | Charpente bois local
14 x Lisse d'ossature | ANG | Habillage en tasseau bois | Façade | PredefinedType: STUD
19 x Lisse d'ossature | ANG | Habillage en tasseau bois | Façade
25 x Raidisseur et chainage | Béton | Raidisseurs et chainage | Fondation et ouvrage de maçonnerie
118 x Poteau moisé 50/50/150 | ANG | Ferme et poteau | Charpente bois local | PredefinedType: STUD
28 x Pied de poteau | Acier Galvanisé | Ferme et poteau | Charpente bois local | PredefinedType: STUD
10 x Pied de poteau | Acier Galvanisé | Ferme et poteau | Charpente bois local
30 x Traverse 120x120 | ANG | Ferme et poteau | Charpente bois local
23 x Rideau métallique | Acier | Façade | Façade | PredefinedType: STUD
419 x Rideau métallique | Acier Galvanisé | Façade | Façade
 | Acier | Façade | Façade | PredefinedType: STUD
10 x Planche de rive 22x200 | GRG | Planches de rive périphériques | Couverture et gestion des EP
524 x Tasseau 50x50 | ANG | Habillage en tasseau bois | Façade | PredefinedType: STUD
4 x Poinçon | ANG | Ferme et poteau | Charpente bois local | PredefinedType: STUD
6 x Panne 50x120 | ANG | Pannes, chevrons, supports de couverture | Charpente bois local
43 x Bardage 22mm + Support 55x85 + Isolant thermique 80mm | Angélique-Revêtement | Option 1 - Bardage sur maçonnerie | Option | Cadwork3dProperties - SKU: PD-Plein
32 x CV 120x120 | ANG | Ferme et poteau | Charpente bois local
12 x 33466A TILOS Brown ceiling fan | PVC | 33466A | Electrical Fixtures | PredefinedType: STUD
102 x 33466A TILOS Brown ceiling fan | PVC | 33466A | Electrical Fixtures
12 x 33466A TILOS Brown ceiling fan | Acier | 33466A | Electrical Fixtures
6 x 33466A TILOS Brown ceiling fan | BA13 | 33466A | Electrical Fixtures
6 x 33466A TILOS Brown ceiling fan | Acier | 33466A | Electrical Fixtures | PredefinedType: STUD
16 x Raidisseur 15x15 | Béton | Raidisseurs et chainage | Fondation et ouvrage de maçonnerie | PredefinedType: STUD
9 x Solive 50x120 | ANG | Plancher bois en plafond du stockage | Charpente bois local
12 x Fer plat 50x10 | Acier Galvanisé | Habillage en tasseau bois | Façade | PredefinedType: STUD
4 x Cornière LNP 50x4 | Acier Galvanisé | Habillage en tasseau bois | Façade
4 x Porte métallique double battant | Acier Galvanisé | Façade | Façade
13 x Porte métallique double battant | Acier Galvanisé | Façade | Façade | PredefinedType: STUD
3 x Porte métallique double battant | Acier | Façade | Façade | PredefinedType: STUD
Poutre Linteau | ANG | Raidisseurs et chainage | Fondation et ouvrage de maçonnerie
8 x CV entre panne 50x120 | ANG | Pannes, chevrons, supports de couverture | Couverture et gestion des EP
9 x Echantignole 120 | ANG
6 x Béquille sur plaque aluminium | Acier | Façade | Façade | PredefinedType: STUD
12 x Béquille sur plaque aluminium | Acier | Façade | Façade
3 x PI93 âme pleine prépeint | Fermacell | Façade | Façade | PredefinedType: STUD
3 x Bati cellumat 100 - 50x120 | ANG | Façade | Façade
6 x Bati cellumat 100 - 50x120 | ANG | Façade | Façade | PredefinedType: STUD
15 x DEP aluminium 70x110 | Zinc | EP | Couverture et gestion des EP | PredefinedType: STUD; Cadwork3dProperties - Partie bâtiment: Charpente
5 x DEP aluminium 70x110 | Zinc | EP | Couverture et gestion des EP | Cadwork3dProperties - Partie bâtiment: Charpente
3 x Gouttière aluminium Typy G300 | Zinc | EP | Couverture et gestion des EP | Cadwork3dProperties - Partie bâtiment: Charpente
234 x Lame 35x150 | ANG |  | Option 3 - Cloison extérieure bois
30 x Rail UNP 50x25 | Acier Galvanisé |  | Option 3 - Cloison extérieure bois | PredefinedType: STUD
5 x Poteau 150x150 | ANG | Raidisseurs et chainage | Fondation et ouvrage de maçonnerie
15 x Raidisseur 15x250 | Béton | Raidisseurs et chainage | Fondation et ouvrage de maçonnerie | PredefinedType: STUD

# IfcPlate (4)
In: Storey 1
Material: OSB 3
Cadwork3dProperties - Group: Charpente bois local; No. production list: 0; Sub group: Plancher bois en plafond du stockage
